# IAR project Demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: Source\Examples; Source; STM8S_StdPeriph_Driver\inc; STM8S_StdPeriph_Driver\src
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Source
    Source/: main.c
  group Source/Examples
    Source/Examples/: user_globalDef.h
  group Source/Examples/ADC
    Source/Examples/: user_adc.c user_adc.h user_adc_example1.c user_adc_example1.h
  group Source/Examples/CLK
    Source/Examples/: user_clk.c user_clk.h
  group Source/Examples/GPIO
    Source/Examples/: user_gpio.c user_gpio.h user_gpio_example1.c user_gpio_example1.h
  group Source/Examples/i2c
    Source/Examples/: user_i2c.c user_i2c.h user_i2c_example1.c user_i2c_example1.h
  group Source/Examples/IWDG
    Source/Examples/: user_iwdg.c user_iwdg.h user_iwdg_example1.c user_iwdg_example1.h
  group Source/Examples/TIM1
    Source/Examples/: user_tim1.c user_tim1.h user_tim1_example1.c user_tim1_example1.h
  group Source/Examples/TIM2
    Source/Examples/: user_tim2.c user_tim2.h user_tim2_example1.c user_tim2_example1.h
  group Source/Examples/TIM3
    Source/Examples/: user_tim3.c user_tim3.h user_tim3_example1.c user_tim3_example1.h
  group Source/Examples/TIM4
    Source/Examples/: user_tim4.c user_tim4.h user_tim4_example1.c user_tim4_example1.h
  group Source/Examples/WWDG
    Source/Examples/: user_wwd.c user_wwd.h user_wwd_example1.c user_wwd_example1.h
  group STM8S_StdPeriph_Driver/inc
    STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_adc1.h stm8s_clk.h stm8s_conf.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_i2c.h stm8s_iwdg.h stm8s_spi.h stm8s_tim1.h stm8s_tim2.h stm8s_tim3.h stm8s_tim4.h stm8s_uart2.h stm8s_wwdg.h
  group STM8S_StdPeriph_Driver/src
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_iwdg.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart2.c stm8s_wwdg.c
